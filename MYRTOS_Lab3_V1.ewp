# IAR project MYRTOS_Lab3_V1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: D:\IAR_WorkSpace\MYRTOS_Lab3_V1\MYRTOS_Lab3_V1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: CortexM.c CortexM.h CortexM_Reg.h GPIO.c GPIO.h GPIO_config.c GPIO_config.h GPIO_reg.h GPTM.C GPTM.h GPTM_config.c GPTM_config.h GPTM_reg.h lstd.h main.c NVIC.c NVIC.h NVIC_config.h NVIC_reg.h Scheduler.c Scheduler.h startup_ewarm.c SystemControl.c SystemControl.h SystemControl_Config.c SystemControl_config.h SystemControl_reg.h SystickTimer.c SystickTimer.h SystickTimer_reg.h Task.c Task.h
